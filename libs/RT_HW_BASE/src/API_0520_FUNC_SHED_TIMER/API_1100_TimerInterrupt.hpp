//+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
//
//								УПРАВЛЕНИЕ ЗАДАЧАМИ ПО ТАЙМЕРУ 
//
// Как это работает??? Здесь нужно описание
//
// Предложения:
//   Мне кажется, что в нашем случае при программировании встроенных систем
//   размещать что-то в приватной области является надуманным.
//   Я избегаю этого.
//   В нашем случае все функции были бы собраны подряд в одном месте и это было бы нагляднее.
//+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
#ifndef   RT_HW_TIMER_hpp
#define   RT_HW_TIMER_hpp
//=================================================================================================
	#define   RT_HW_TIMER_VER_NUM    	(uint16_t)100		//--Номер версии;
	#define   RT_HW_TIMER_VER_NAME 	"v.1.0.0 28.03.2025"	//--Наименование версии;
	#include "RT_HW_BASE.h"
	#if defined(RT_HW_SUPPORTS_TASK_TIMER) && defined(RT_HW_PERMIT_TASK_TIMER)
		#define RT_HW_TASK_TIMER_OK		//--Разрешение использования функций прерываний от таймера;
	#endif
//-------------------------------------------------------------------------------------------------
	#if defined(RT_HW_TASK_TIMER_OK)
		#include <TimerInterrupt_Generic.h>
	#endif
//=================================================================================================
//										CLASS RT_HW_Timer
//=================================================================================================
class RT_HW_Timer {
public:
    typedef void (*Callback)();
//-------------------------------------------------------------------------------------------------
//										1.Конструктор
//-------------------------------------------------------------------------------------------------
  RT_HW_Timer() : taskCount(0), taskCapacity(2), nextId(0) {
        tasks = (Task*)malloc(sizeof(Task) * taskCapacity);
		#if defined(RT_HW_TASK_TIMER_OK)
			instance = this;
			timer.init(0);
			timer.attachInterruptInterval(1000 * BASE_INTERVAL_MS, tickISR);
		#endif
  };
//-------------------------------------------------------------------------------------------------
//										2.Деструктор
//-------------------------------------------------------------------------------------------------
  ~RT_HW_Timer() {free(tasks);};
//-------------------------------------------------------------------------------------------------
//										3.
//-------------------------------------------------------------------------------------------------
  int every(uint32_t intervalMs, Callback cb) {
     if(taskCount >= taskCapacity) {if (!expandTasks()) {return -1;}}

        tasks[taskCount].callback = cb;
        tasks[taskCount].interval = intervalMs;
        tasks[taskCount].last = millis();
        tasks[taskCount].id = nextId++;
        ++taskCount;
        return tasks[taskCount - 1].id;
    }
//-------------------------------------------------------------------------------------------------
//										4.
//-------------------------------------------------------------------------------------------------
    bool cancel(int taskId) {
        for (int i = 0; i < taskCount; ++i) {
            if (tasks[i].id == taskId) {
                for (int j = i; j < taskCount - 1; ++j) {
                    tasks[j] = tasks[j + 1];
                }
                --taskCount;
                return true;
            }
        }
        return false;
    }
//-------------------------------------------------------------------------------------------------
//										5.
//-------------------------------------------------------------------------------------------------
  void update() {
	#if defined(RT_HW_TASK_TIMER_OK)
        tick();
	#endif
  };
//+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
private:
    struct Task {
        Callback callback;
        uint32_t interval;
        uint32_t last;
        int id;
    };

    Task* tasks;
    int taskCount;
    int taskCapacity;
    int nextId;

    static const uint32_t BASE_INTERVAL_MS = 1;
//-------------------------------------------------------------------------------------------------
//										6.
//-------------------------------------------------------------------------------------------------
    bool expandTasks() {
        int newCapacity = taskCapacity * 2;
        Task* newTasks = (Task*)realloc(tasks, sizeof(Task) * newCapacity);
        if (!newTasks) return false;
        tasks = newTasks;
        taskCapacity = newCapacity;
        return true;
    }
//-------------------------------------------------------------------------------------------------
//										7.
//-------------------------------------------------------------------------------------------------
    void tick() {
        unsigned long now = millis();
        for (int i = 0; i < taskCount; ++i) {
            if (now - tasks[i].last >= tasks[i].interval) {
                tasks[i].last = now;
                tasks[i].callback();
            }
        }
    }

	#if defined(RT_HW_TASK_TIMER_OK)
		static RT_HW_Timer* instance;
		static TimerInterrupt_Generic timer;
//-------------------------------------------------------------------------------------------------
//										8.
//-------------------------------------------------------------------------------------------------
		static void tickISR() {if (instance) instance->tick();}
	#endif

};	//==END 
//-------------------------------------------------------------------------------------------------
//										9.
//-------------------------------------------------------------------------------------------------
	#if defined(RT_HW_TASK_TIMER_OK)
		TimerInterrupt_Generic RT_HW_Timer::timer;
		RT_HW_Timer* RT_HW_Timer::instance = nullptr;
	#endif

//=================================================================================================	
#endif	
